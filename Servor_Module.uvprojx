# Keil uVision project Servor_Module.uvprojx, settings and files
target Servor_Module (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Servor_Module +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CORE;.\FWlib\inc;.\HARDWARE\Beep;.\HARDWARE\Common;.\HARDWARE\LED;.\HARDWARE\Timer;.\SYSTEM\delay;.\SYSTEM\sys;.\USER;.\HARDWARE\motor4;.\HARDWARE\encod;.\SYSTEM\usart;.\HARDWARE\UWB;.\HARDWARE\OSAL;.\HARDWARE\control;.\HARDWARE\OLED;.\HARDWARE\Data display
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/Beep/: beep.c
    ./HARDWARE/Common/: common.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/Timer/: timer.c
    ./HARDWARE/motor4/: motor4.c
    ./HARDWARE/encod/: encod.c
    ./HARDWARE/UWB/: uwb.c
    ./HARDWARE/OSAL/: OSAL.c
    ./HARDWARE/control/: control.c
    ./HARDWARE/OLED/: oled_i2c.c
    ./HARDWARE/Data display/: Data_display.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: hal_usart.c
software components: CMSIS:CORE 4.3.0
